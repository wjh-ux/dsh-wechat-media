# Keil uVision project blink.uvprojx, settings and files
target STM32F103C8 (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x8000000,0x10000) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: blink +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=2 wLevel=2
  scatter file: .\blink.sct
  group App
    ./: main.c
  group Startup
    ./: startup_stm32f10x_md.s
